# Keil uVision project FROM PC 13 TO TOGGLE OUTPUT AT PA5.uvproj, settings and files
target Target 1 (MCS-51)
  device: uPSD3434EV STMicroelectronics
  cpu: IRAM(0 - 0xFF) CLOCK(40000000) XRAM(0x2000 - 0x3FFF) MODH2
  output: FROM PC 13 TO TOGGLE OUTPUT AT PA5
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP34.A51
