# Keil uVision project A BARE-METAL DRIVE R TO TOGGLE GPIOA PIN 5.uvproj, settings and files
target Target 1 (MCS-51)
  device: uPSD3212A STMicroelectronics
  cpu: IRAM(0-0xFF) CLOCK(40000000)  XRAM (0x2000-0x3FFF)
  output: A BARE-METAL DRIVE R TO TOGGLE GPIOA PIN 5
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTU32.A51
